# Repository sirkha/3D-Components

File README.md:

3D Components
=============

These are various components and assemblies that I have modeled for use 
in designing 3D printed objects.

I hope you can find some of them as useful as I have.

License
-------
[CC-BY-SA][7]

Attribution
-----------
Thanks to [Adafruit][1] and [Arduino][2] for putting their pcb files on the 
web, which makes the assemblies possible. Also, thanks to [kcswalter][9] for his
excellent 3D models, which I made heavy use of.

Thanks to the following open source software packages:
* [Blender][3]
* [FreeCAD][4]
* [OpenSCAD][5]
* [Inkscape][6]
* [Kicad][8]

[1]: http://adafruit.com "Adafruit Industries"
[2]: http://arduino.cc "Arduino"
[3]: http://blender.org "Blender"
[4]: http://freecad.org "FreeCAD"
[5]: http://openscad.org "OpenSCAD"
[6]: http://inkscape.org "Inkscape"
[7]: https://creativecommons.org/licenses/by-sa/2.0/legalcode "CC-BY-SA"
[8]: http://kicad-pcb.org "Kicad"
[9]: http://smisioto.no-ip.org/elettronica/kicad/kicad-en.htm "Walter Kicad Libs"

## KiCad design Assemblies/Adafruit-1.27inch-Color-OLED-Breakout-PCB-master/Adafruit 1.27 128x96 RGB OLED.kicad_pcb

Board: 2 copper layers, 43.2 x 35.6 mm, 33 parts (0 on the bottom side), 27 nets.

Parts:
C1, C2: 10uF/16V; _0805MP
C3, C4: 1.0uF; _0805MP
C5, C6, C7, C9: 10uF; _0805MP
C8: 0.1uF; _0805MP
CN1: microSD; MICROSD
D1, D3: 1N4148; SOD-323
D2: BAT54T1G; SOD-123
JP1: 1X11_ROUND
L1: 10uH; INDUCTOR_1007
R4: 600K; _0805MP
R5: 50; _0805MP
R6: 100K; _0805MP
R7, R8: 10K; _0805MP
SJ1: BS0; SOLDERJUMPER_REFLOW_NOPASTE
U1: UG-2828GDEDF11; FPC_XF2M-3015-1A
U2: MIC5225-3.3v; SOT23-5
U3: FAN5331SX; SOT23-5@1
U4: 74HC4050D; SOIC16
U$22, U$23, U$24, U$25: MOUNTINGHOLE2.5; MOUNTINGHOLE_2.5_PLATED
U$26, U$27, U$29: FIDUCIAL; FIDUCIAL_1MM
U$28: ADAFRUIT_3.5MM

Connections:
3.3V: C3.2, C5.1, C7.1, C9.1, CN1.4, JP1.9, L1.P$1, SJ1.2, U1.P$4, U1.P$27, U2.5, U3.4, U3.5, U4.1
13V: C1.2, C8.1, D2.C, R6.2, U1.P$29
DC: JP1.3, U4.3
GND: C1.1, C2.2, C3.1, C4.2, C5.2, C6.2, C7.2, C9.2, CN1.6, CN1.MT1, CN1.MT2, D3.C, JP1.11, R4.1, R7.1, R8.1, U1.P$1, U1.P$3, U1.P$13, U1.P$30, U2.2, U3.2, U4.8
IREF: R4.2, U1.P$9
MOSI/DATA1: CN1.3, U1.P$18, U4.12
unnamed: C4.1, U1.P$5
unnamed: D2.A, L1.P$2, U3.1
unnamed: R5.2, U1.P$26
unnamed: D1.A, R5.1
unnamed: C8.2, R6.1, R7.2, U3.3
unnamed: D1.C, D3.A
unnamed: JP1.1, U4.11
unnamed: JP1.2, U4.14
OCS: JP1.5, U4.7
OLED_BS0: R8.2, SJ1.1, U1.P$14
OLED_CS: U1.P$12, U4.6
OLED_DC: U1.P$11, U4.2
OLED_RES: U1.P$10, U4.4
RESET: JP1.4, U4.5
SCK/DATA0: CN1.5, U1.P$17, U4.15
SCS: JP1.6, U4.9
SD_CD: CN1.CD1, JP1.8
SD_CS: CN1.2, U4.10
SD_DOUT: CN1.7, JP1.7
VCOMH: C2.1, U1.P$28
VIN: C6.1, JP1.10, U2.1, U2.3

## KiCad design Assemblies/2.8-TFT-Breakout-PCB-master/Adafruit 2.8 TFT Breakout v2.kicad_pcb

Board: 16 copper layers, 62.5 x 81.3 mm, 38 parts (0 on the bottom side), 50 nets.

Parts:
C1, C4: 0.1uF; 0805-NO
C2, C3, C5: 10uF; 0805-NO
IC1: MIC5225-3.3; SOT23-5L
IC2, IC3: 74LVC245; SO20W
IC4: APX803-SAG; SOT23
JP1, JP2: 1X20_ROUND
Q1: MMBT2222; SOT23-BEC
R1, R2, R3, R4: 10; 0805-NO
R5, R7: 1K; 0805-NO
R6: 10K; R0805
R8, R9, R10, R11, R12: 10K; 0805-NO
SJ1, SJ2, SJ3, SJ4: SOLDERJUMPER_ARROW_NOPASTE
U$7, U$15, U$16, U$17: MOUNTINGHOLE3.0THIN; MOUNTINGHOLE_3.0_PLATEDTHIN
U$9, U$11, U$23: FIDUCIAL; FIDUCIAL_1MM
U$10: DISP_LCD_1.28IN_240X320_50PIN; TFT_2.83IN_240X320_50PIN
U$19: ADAFRUIT_TEXT_30MM
X1: MICROSD

Connections:
+5V: C2.1, C5.1, IC1.1, IC1.3, JP1.2, JP2.2, R7.2
CARDDET: JP2.20, X1.CD2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, IC1.2, IC2.10, IC2.19, IC3.10, IC3.19, IC4.1, JP1.1, JP2.1, Q1.E, R8.1, R9.1, R10.2, R11.2, R12.1, U$10.43, U$10.48, U$10.49, U$10.50, X1.6, X1.MT1, X1.MT2
IM0: JP2.18, R8.2, SJ1.1, U$10.6
IM1: JP2.17, R9.2, SJ2.1, U$10.7
IM2: JP2.16, R11.1, SJ3.2, U$10.8
IM3: JP2.15, R10.1, SJ4.2, U$10.9
LCD_CS: IC3.15, U$10.38
LCD_CS_5V: IC3.5, JP1.3, JP2.7
LCD_DATA0: IC2.18, U$10.32
LCD_DATA0_5V: IC2.2, JP1.13
LCD_DATA1: IC2.17, U$10.31
LCD_DATA1_5V: IC2.3, JP1.14
LCD_DATA2: IC2.16, U$10.30
LCD_DATA2_5V: IC2.4, JP1.15
LCD_DATA3: IC2.15, U$10.29
LCD_DATA3_5V: IC2.5, JP1.16
LCD_DATA4: IC2.14, U$10.28
LCD_DATA4_5V: IC2.6, JP1.17
LCD_DATA5: IC2.13, U$10.27
LCD_DATA5_5V: IC2.7, JP1.18
LCD_DATA6: IC2.12, U$10.26
LCD_DATA6_5V: IC2.8, JP1.19
LCD_DATA7: IC2.11, U$10.25
LCD_DATA7_5V: IC2.9, JP1.20
LCD_LITE: JP1.8, JP2.10, R5.1, R7.1
LCD_RD: IC3.12, U$10.35
LCD_RD_5V: IC2.1, IC3.8, JP1.6, R12.2
LCD_RS: IC3.14, U$10.37, X1.5
LCD_RST: IC3.11, U$10.10
LCD_RST_5V: IC3.9, IC4.2, JP1.7, JP2.9, R6.1
LCD_RS_5V: IC3.6, JP1.4, JP2.4
LCD_WR: IC3.13, U$10.36
LCD_WR_5V: IC3.7, JP1.5, JP2.8
LCD_X+: JP1.9, JP2.12, U$10.46
LCD_X-: JP1.11, JP2.14, U$10.44
LCD_Y+: JP1.10, JP2.11, U$10.47
LCD_Y-: JP1.12, JP2.13, U$10.45
unnamed: R4.2, U$10.5
unnamed: R1.2, U$10.2
unnamed: R2.2, U$10.3
unnamed: R3.2, U$10.4
unnamed: Q1.C, U$10.1
unnamed: Q1.B, R5.2
SDI_3V: IC3.16, U$10.34, X1.3
SDI_5V: IC3.4, JP2.6
SDO: JP2.5, U$10.33, X1.7
SD_CS_3V: IC3.17, X1.2
SD_CS_5V: IC3.3, JP2.19
VCC: C1.1, C3.1, C4.1, IC1.5, IC2.20, IC3.1, IC3.20, IC4.3, JP2.3, R1.1, R2.1, R3.1, R4.1, R6.2, SJ1.2, SJ2.2, SJ3.1, SJ4.1, U$10.40, U$10.41, U$10.42, X1.4

## KiCad design Assemblies/Adafruit-NeoPixel-Ring-master/Adafruit NeoPixel Ring 24 B.kicad_pcb

Board: 2 copper layers, 65.5 x 65.5 mm, 49 parts (0 on the bottom side), 3 nets.

Parts:
C2, C3, C4, C5, C7, C8, C10, C12, C14, C16, C17, C19, C20, C21, C22: C0603
FID1, FID2: FIDUCIAL; FIDUCIAL_1MM
JP1, JP2, JP3, JP4, JP5, JP6: 1X01-CLEANBIG
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED15, LED16, LED17, LED18, LED19, LED20, LED21, LED22, LED23, LED24: WS2812B5050; WS2812B-NARROW
R1: 0603-NO
U$1: ADAFRUIT_5MM

Connections:
GND: C2.2, C3.2, C4.2, C5.2, C7.2, C8.2, C10.2, C12.2, C14.2, C16.2, C17.2, C19.2, C20.2, C21.2, C22.2, JP4.1, JP6.1, LED1.3-GN, LED2.3-GN, LED3.3-GN, LED4.3-GN, LED5.3-GN, LED6.3-GN, LED7.3-GN, LED8.3-GN, LED9.3-GN, LED10.3-GN, LED11.3-GN, LED12.3-GN, LED13.3-GN, LED14.3-GN, LED15.3-GN, LED16.3-GN, LED17.3-GN, LED18.3-GN, LED19.3-GN, LED20.3-GN, LED21.3-GN, LED22.3-GN, LED23.3-GN, LED24.3-GN
unnamed: JP1.1, R1.1
VDD: C2.1, C3.1, C4.1, C5.1, C7.1, C8.1, C10.1, C12.1, C14.1, C16.1, C17.1, C19.1, C20.1, C21.1, C22.1, JP3.1, JP5.1, LED1.1-VD, LED2.1-VD, LED3.1-VD, LED4.1-VD, LED5.1-VD, LED6.1-VD, LED7.1-VD, LED8.1-VD, LED9.1-VD, LED10.1-VD, LED11.1-VD, LED12.1-VD, LED13.1-VD, LED14.1-VD, LED15.1-VD, LED16.1-VD, LED17.1-VD, LED18.1-VD, LED19.1-VD, LED20.1-VD, LED21.1-VD, LED22.1-VD, LED23.1-VD, LED24.1-VD

## KiCad design Assemblies/Arduino-MegaADK/ADK_MEGA_2560-REV3-append.kicad_pcb

Board: 2 copper layers, 101.6 x 53.3 mm, 100 parts (0 on the bottom side), 130 nets.

Parts:
@HOLE0, @HOLE1, @HOLE2, @HOLE3, @HOLE4, @HOLE5: (no value)
ADCH: 8x1F-H8.5; 1X08
ADCL: 8x1F-H8.5; 1X08
C1, C12, C13, C19, C20: 22p; C0603-ROUND
C2: 10n; C0603-ROUND
C3, C6, C7, C8, C9, C10, C11, C14, C15, C17, C18, C21, C22, C24, C25, C26: 100n; C0603-ROUND
C4, C5: 10u; SMC_B
C16, C23: 1u; C0603-ROUND
COMMUNICATION: 8x1F-H8.5; 1X08
D1, D4, D5: CD1206-S01575; MINIMELF
D2: M7; SMB
D3: SS1P3L; DO220AAL
F1, F2: MF-MSMF050-2 500mA; L1812
FID1, FID2, FID3, FID4: FIDUCIALMOUNT; FIDUCIA-MOUNT
GROUND: SJ
IC1: LMV358IDGKR; MSOP08
IC2: LM2734Y; SOT23-6
IC3: ATMEGA2560-16AU; TQFP100
IC4: ATMEGA16U2-MUR; MLF32
IC5, IC6, IC8, IC9: 74LVC1G125DCK; SC70-5
IC7: LP2985-33DBVR; SOT23-DBV
ICSP, ICSP1: 3x2M; 2X03
JP1: 10x1F-H8.5; 1X10
L: YELLOW; CHIP-LED0805
L1: 10u SRR0604-100ML; SRR0604
L2, L3: MH2029-300Y; 0805
ON: GREEN; CHIP-LED0805
PC1: 10u; SMC_B
POWER: 8x1F-H8.5; 1X08
PWML: 8x1F-H8.5; 1X08
R1: 100k; R0603-ROUND
R2: 52K3; R0603-ROUND
R3: 10K; R0603-ROUND
R5, R6, R9: 0R; R0402
RESET: TS42
RESET-EN: SJ
RN1, RN3, RN6: 10K; CAT16
RN2, RN5: 1k; CAY16
RN4, RN7: 22R; CAY16
RX: YELLOW; CHIP-LED0805
SJ1, SJ2, SJ3: NM; J0402
T1: FDN340P; SOT-23
TX: YELLOW; CHIP-LED0805
U7A: MAX3421EEHJ; TQFP32-05
X1: JACK 2mm; POWERSUPPLY_DC-21MM
X2: USB B-TH; PN61729
X3: USB A-TH; PN87520-S
XIO: 18x2F-H8.5; 2X18
Y1: 16MHz CSTCE16M0V53-R0; RESONATOR
Y2: 16MHz KX-7; CRYSTAL-3.2-2.5
Y3: 12MHz KX-7; CRYSTAL-3.2-2.5
Z1, Z2, Z3, Z4: CG0603MLC-05E; CT%2fCN0603

Connections:
+3V3: C18.1, C23.2, C25.1, C26.1, IC1.6, IC5.5, IC6.5, IC7.5, IC8.5, IC9.5, POWER.4, RN6.1, U7A.2, U7A.23
+5V: C5.+, C7.1, C8.1, C9.1, C14.1, C15.1, C21.2, D1.A, D4.C, D5.C, IC1.8, IC3.10, IC3.31, IC3.61, IC3.80, IC3.100, IC4.4, IC4.32, IC7.1, IC7.3, ICSP.2, ICSP1.2, L1.P$2, L3.1, POWER.2, POWER.5, R2.1, RN1.1, RN1.2, RN1.6, RN2.2, RN2.3, RN2.6, RN3.1, RN5.5, RN5.6, RN6.7, T1.2, XIO.1, XIO.2
ADC0: ADCL.1, IC3.97
ADC1: ADCL.2, IC3.96
ADC2: ADCL.3, IC3.95
ADC3: ADCL.4, IC3.94
ADC4: ADCL.5, IC3.93
ADC5: ADCL.6, IC3.92
ADC6: ADCL.7, IC3.91
ADC7: ADCL.8, IC3.90
ADC8: ADCH.1, IC3.89
ADC9: ADCH.2, IC3.88
ADC10: ADCH.3, IC3.87
ADC11: ADCH.4, IC3.86
ADC12: ADCH.5, IC3.85
ADC13: ADCH.6, IC3.84
ADC14: ADCH.7, IC3.83
ADC15: ADCH.8, IC3.82
AREF: C6.1, IC3.98, JP1.3
BOOST: C2.1, D1.C, IC2.1
CMP: C22.2, IC1.5, RN3.2, RN3.3
D+: RN4.5, X2.3, Z2.2
D-: RN4.8, X2.2, Z1.2
DTR: C10.1, IC4.13, RN2.4
EN: IC2.4, R1.2
FB: IC2.3, R2.2, R3.1
GATE_CMD: IC1.7, T1.3
GND: C1.2, C3.2, C4.-, C5.-, C6.2, C7.2, C8.2, C9.2, C11.2, C12.2, C13.2, C14.2, C15.2, C17.2, C18.2, C19.1, C20.1, C21.1, C22.1, C23.1, C24.2, C25.2, C26.2, D2.A, D3.P$2, GROUND.2, IC1.4, IC2.2, IC3.11, IC3.32, IC3.62, IC3.81, IC3.99, IC4.3, IC4.33, IC5.1, IC5.3, IC6.1, IC6.3, IC7.2, IC8.1, IC8.3, IC9.1, IC9.3, ICSP.6, ICSP1.6, JP1.4, L.C, ON.C, PC1.-, POWER.6, POWER.7, R3.2, RESET.1, RESET.2, RN2.5, RN3.7, RN6.5, U7A.3, U7A.19, X1.1, X1.3, X3.4, XIO.35, XIO.36, Y1.2, Y2.2, Y2.4, Y3.2, Y3.4
GPX_MAX: IC3.66, U7A.17
INT_MAX: RN6.8, SJ3.2, U7A.18
L13: IC1.1, IC1.2, RN2.1
M8RXD: IC4.9, RN5.7
M8TXD: IC4.8, RN5.8
MISO2: IC4.17, ICSP1.1
MOSI2: IC4.16, ICSP1.4
MOSI_3V3: IC9.4, U7A.16
unnamed: L.A, RN2.8
unnamed: ON.A, RN2.7
unnamed: RN7.1, X3.2, Z4.2
unnamed: RN7.4, X3.3, Z3.2
unnamed: RN7.8, U7A.20
unnamed: RN7.5, U7A.21
unnamed: F2.2, X3.1
unnamed: C20.2, U7A.24, Y3.1
unnamed: C19.2, U7A.25, Y3.3
unnamed: C17.1, F2.1, L3.2
unnamed: C24.1, U7A.22
unnamed: RN5.4, RX.A
unnamed: RN5.3, TX.A
PA0: IC3.78, XIO.3
PA1: IC3.77, XIO.4
PA2: IC3.76, XIO.5
PA3: IC3.75, XIO.6
PA4: IC3.74, XIO.7
PA5: IC3.73, XIO.8
PA6: IC3.72, XIO.9
PA7: IC3.71, XIO.10
PB0_SS: IC3.19, SJ2.3, XIO.34
PB1_SCK: IC3.20, IC6.2, ICSP.3, XIO.33
PB2_MOSI: IC3.21, IC9.2, ICSP.4, XIO.32
PB3_MISO: IC3.22, ICSP.1, U7A.15, XIO.31
PB4: IC3.23, JP1.8
PB5: IC3.24, JP1.7
PB6: IC3.25, JP1.6
PB7: IC1.3, IC3.26, JP1.5
PC0: IC3.53, XIO.18
PC1: IC3.54, XIO.17
PC2: IC3.55, XIO.16
PC3: IC3.56, XIO.15
PC4: IC3.57, XIO.14
PC5: IC3.58, XIO.13
PC6: IC3.59, XIO.12
PC7: IC3.60, XIO.11
PD7: IC3.50, XIO.19
PE0: IC3.2, PWML.1, RN5.2
PE1: IC3.3, PWML.2, RN5.1
PE3: IC3.5, PWML.6
PE4: IC3.6, PWML.3
PE5: IC3.7, PWML.4
PE6: IC3.8, SJ3.3
PG0: IC3.51, XIO.22
PG1: IC3.52, XIO.21
PG2: IC3.70, XIO.20
PG5: IC3.1, PWML.5
PH3: IC3.15, PWML.7
PH4: IC3.16, PWML.8, SJ1.1
PH5: IC3.17, JP1.10
PH6: IC3.18, JP1.9
PH7: IC3.27, SJ2.1
PJ2: IC3.65, SJ1.3
PJ6: IC3.69, SJ3.1
PL0: IC3.35, XIO.30
PL1: IC3.36, XIO.29
PL2: IC3.37, XIO.28
PL3: IC3.38, XIO.27
PL4: IC3.39, XIO.26
PL5: IC3.40, XIO.25
PL6: IC3.41, XIO.24
PL7: IC3.42, XIO.23
RD+: IC4.29, RN4.4
RD-: IC4.30, RN4.1
RESET: C1.1, C10.2, D5.A, IC3.30, ICSP.5, POWER.3, RESET.3, RESET.4, RESET-EN.1, RESET-EN.2, RN1.7
RESET2: D4.A, IC4.24, ICSP1.5, RN3.8
RST_3V3: IC5.4, U7A.12
RST_5V: IC5.2, RN6.4, SJ1.2
RXD1: COMMUNICATION.3, IC3.45
RXD2: COMMUNICATION.5, IC3.12
RXD3: COMMUNICATION.7, IC3.63
RXL: IC4.10, RX.C
SCK2: IC4.15, ICSP1.3
SCK_3V3: IC6.4, U7A.13
SCL: COMMUNICATION.1, IC3.43, JP1.1, RN1.8
SDA: COMMUNICATION.2, IC3.44, JP1.2, RN1.3
SS_3V3: IC8.4, U7A.14
SS_MAX5: IC8.2, RN6.2, SJ2.2
SW: C2.2, D3.P$1, IC2.6, L1.P$1
TXD1: COMMUNICATION.4, IC3.46
TXD2: COMMUNICATION.6, IC3.13
TXD3: COMMUNICATION.8, IC3.64
TXL: IC4.11, TX.C
UGND: C16.2, GROUND.1, IC4.28, L2.1, X2.4
USBVCC: C11.1, F1.1, IC4.31, T1.1
USHIELD: L2.2, X2.P$1, X2.P$2, X3.S1, X3.S2, Z1.1, Z2.1, Z3.1, Z4.1
VIN: C3.1, C4.+, D2.C, IC2.5, PC1.+, POWER.8, R1.1, RN3.6, X1.2
VUCAP: C16.1, IC4.27
XT1: C13.1, IC4.1, Y2.1
XT2: C12.1, IC4.2, Y2.3
XTAL1: IC3.34, Y1.3
XTAL2: IC3.33, Y1.1
XVCC: F1.2, X2.1

## KiCad design Assemblies/NeoPixel-Sticks-master/Adafruit NeoPixel 8 Stick.kicad_pcb

Board: 2 copper layers, 50.8 x 10.2 mm, 24 parts (0 on the bottom side), 11 nets.

Parts:
C1, C2, C3, C4, C5, C6, C7, C8: C0805K
CN1, CN2: 1X4SMT; 1X4-SMT
FID1, FID3: FIDUCIAL; FIDUCIAL_1MM
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8: WS28115050
U$1: ADAFRUIT_TEXT_20MM
U$2, U$3: MOUNTINGHOLE2.0; MOUNTINGHOLE_2.0_PLATED
U$4: ADAFRUIT_2.5MM

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, CN1.3, CN2.2, LED1.LEDV, LED1.VDD, LED2.LEDV, LED2.VDD, LED3.LEDV, LED3.VDD, LED4.LEDV, LED4.VDD, LED5.LEDV, LED5.VDD, LED6.LEDV, LED6.VDD, LED7.LEDV, LED7.VDD, LED8.LEDV, LED8.VDD
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, CN1.1, CN1.4, CN2.1, CN2.4, LED1.VSS, LED2.VSS, LED3.VSS, LED4.VSS, LED5.VSS, LED6.VSS, LED7.VSS, LED8.VSS
unnamed: LED1.DO, LED2.DI
unnamed: LED2.DO, LED3.DI
unnamed: LED3.DO, LED4.DI
unnamed: LED4.DO, LED5.DI
unnamed: LED5.DO, LED6.DI
unnamed: LED6.DO, LED7.DI
unnamed: LED7.DO, LED8.DI
unnamed: CN2.3, LED1.DI
unnamed: CN1.2, LED8.DO

## Commit log

2014-10-07 Missed a quote
2014-10-08 Added some missing attribution.
